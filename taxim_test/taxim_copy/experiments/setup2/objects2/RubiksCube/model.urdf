Commit message: created new object picking method for edag dataset

File: taxim_test/taxim_copy/experiments/setup2/objects2/RubiksCube/model.urdf (robot description, URDF)
Before this commit: robot model.urdf, 1 links, 0 joints
Links:
- link baseLink: mass .369 -> .497
